PACKAGECONFIG_append = " linuxfb eglfs gles2 kms"