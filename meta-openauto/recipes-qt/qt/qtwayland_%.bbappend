PACKAGECONFIG_remove_pn-qtwayland = "xcomposite-glx"
